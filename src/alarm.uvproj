# Keil uVision project alarm.uvproj, settings and files
target stc (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: stc +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app;.\Lib;.\bsp
  group app
    ./app/: main.c spi.c com.c rn8209d.c timerhl.c adchl.c code_switch.c msg_protocol.c eepromhl.c
  group bsp
    ./bsp/: bsp.c
  group Lib
    ./Lib/: ADC.c EEPROM.c GPIO.c timer.c USART.C PCA.c
